# Keil uVision project Calculator.uvproj, settings and files
target Calculator (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: Calculator +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DRI;.\SYS;.\USR
  group USR
    ./USR/: main.c keyscan_advance.c calc.c display.c keyscan_basic.c
  group DRI
    ./DRI/: hc165.c lcd.c I2C.C ZLG7290.c
