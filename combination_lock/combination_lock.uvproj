# Keil uVision project combination_lock.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Atmel
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: combination_lock +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\DRI;.\SYS;.\USR
  group USR
    ./USR/: display.c keyscan.c main.c process.c
  group SYS
    ./SYS/: reg52.h STARTUP.A51
  group DRI
    ./DRI/: hc165.c I2C.C lcd.c ZLG7290.c
